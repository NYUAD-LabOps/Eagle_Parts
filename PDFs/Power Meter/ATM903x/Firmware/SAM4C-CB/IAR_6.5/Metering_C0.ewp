# IAR project Metering_C0.ewp, settings and files
configuration CACHE_ENABLED (ARM, debug)
  General.OGChipSelectEditMenu: SAM4C Atmel SAM4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4=true; __SAM4C16C__; ENABLE_CACHE
  ICCARM.CCIncludePath2: src\__ValidLibs\v_startup\; src\; src\array_dsp_filters; src\asf; src\asf\common; src\asf\common\boards; src\asf\common\services; src\asf\common\services\clock; src\asf\common\services\clock\sam4s; src\asf\common\services\gpio; src\asf\common\services\ioport; src\asf\common\services\ioport\sam; src\asf\common\services\sleepmgr; src\asf\common\services\spi; src\asf\common\services\twi; src\asf\common\services\serial; src\asf\common\services\studio_serial; src\asf\common\services\slcd; src\asf\common\services\delay; src\asf\common\utils; src\asf\common\utils\interrupt; src\asf\common\utils\stdio\stdio_serial; src\asf\common\components\eeprom; src\asf\sam; src\asf\sam\boards; src\__include; src\__include\Devices\SAM4C\split; src\__include\Devices\SAM4C\; src\__include\Devices\_cores\CMSIS\Include; src\asf\sam\drivers; src\asf\sam\drivers\chipid; src\asf\sam\drivers\matrix; src\asf\sam\drivers\pdc; src\asf\sam\drivers\pio; src\asf\sam\drivers\pmc; src\asf\sam\drivers\rstc; src\asf\sam\drivers\rtc; src\asf\sam\drivers\rtt; src\asf\sam\drivers\supc; src\asf\sam\drivers\spi; src\asf\sam\drivers\ipc; src\asf\sam\drivers\uart; src\asf\sam\drivers\usart; src\asf\sam\drivers\wdt; src\asf\sam\drivers\twi; src\asf\sam\drivers\slcd; src\asf\sam\utils; src\asf\sam\utils\preprocessor; src\asf\sam\utils\syscalls; src\asf\thirdparty; src\asf\thirdparty\CMSIS; src\asf\thirdparty\CMSIS\Include; src\asf\thirdparty\CMSIS\Lib; src\asf\thirdparty\CMSIS\Lib\GCC; src\config; src\startup; src\calibration; src\command; src\display; src\dsp; src\host; src\metrology; src\power; src\powerfail; src\debug; src\tamper
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Metering_C0_C1.bin
  ILINK.IlinkOutputFile: Metering_C0_C1.out
  ILINK.IlinkIcfFile: src\__Link\IAR\SAM4C16_FLASH_cache.icf
  ILINK.IlinkExtraOptions: --keep=__checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DEFAULT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ARM_MATH_CM4=true; __SAM4C16C__
  ILINK.IlinkIcfFile: src\__Link\IAR\SAM4C16_FLASH_default.icf
  group src
    src/: asf.h DemoMeter.c DemoMeter.h help.c project.h target.h
  group src/__include
    src/__include/: board.h device.h exceptions.h global.h
  group src/__include/Boards
    src/__include/Boards/: SAM4C_VB_V_Area.h
  group src/__include/Devices
    src/__include/Devices/: iflash_info.h packages.h
  group src/__include/Devices/SAM4C
    src/__include/Devices/SAM4C/: sam4c-0.h
  group src/__include/Devices/SAM4C/split
    src/__include/Devices/SAM4C/split/: sam4c16c-0.h
  group src/__include/Devices/SAM4C/split/component
    src/__include/Devices/SAM4C/split/component/: adc.h aes.h chipid.h cmcc.h efc.h gpbr.h icm.h ipc.h matrix.h pdc.h pio.h pmc.h pwm.h rstc.h rtc.h rtt.h slcdc.h smc.h spi.h supc.h tc.h trng.h twi.h uart.h usart.h wdt.h
  group src/__include/Devices/SAM4C/split/instance
    src/__include/Devices/SAM4C/split/instance/: adc.h aes.h chipid.h cmcc0.h cmcc1.h efc.h gpbr.h icm.h ipc0.h ipc1.h matrix0.h matrix1.h pioa.h piob.h pioc.h pmc.h pwm.h rstc.h rtc.h rtt.h slcdc.h smc0.h smc1.h spi0.h spi1.h supc.h tc0.h tc1.h trng.h twi0.h twi1.h uart0.h uart1.h usart0.h usart1.h usart2.h usart3.h usart4.h wdt.h
  group src/__include/Devices/SAM4C/split/pio
    src/__include/Devices/SAM4C/split/pio/: sam4c16c.h
  group src/__include/Exceptions
    src/__include/Exceptions/: SAM4C_Exceptions.h
  group src/__ValidLibs/v_startup
    src/__ValidLibs/v_startup/: IAR_SAM4C_cstartup.c v_relocate.c v_relocate.h
    src/__Link/IAR/: SAM4C16_FLASH_cache.icf SAM4C16_FLASH_default.icf
  group src/asf/common/boards
    src/asf/common/boards/: board.h system_sam4c.c system_sam4c.h
  group src/asf/common/components/eeprom
    src/asf/common/components/eeprom/: at24cxx.c at24cxx.h
  group src/asf/common/services/clock
    src/asf/common/services/clock/: genclk.h osc.h pll.h sysclk.h
  group src/asf/common/services/clock/sam4c
    src/asf/common/services/clock/sam4c/: genclk.h osc.h pll.h sysclk.c sysclk.h
  group src/asf/common/services/delay
    src/asf/common/services/delay/: delay.h
  group src/asf/common/services/delay/sam
    src/asf/common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group src/asf/common/services/gpio
    src/asf/common/services/gpio/: gpio.h
  group src/asf/common/services/gpio/sam_ioport
    src/asf/common/services/gpio/sam_ioport/: sam_gpio.h
  group src/asf/common/services/ioport
    src/asf/common/services/ioport/: ioport.h
  group src/asf/common/services/ioport/sam
    src/asf/common/services/ioport/sam/: ioport.h
  group src/asf/common/services/serial
    src/asf/common/services/serial/: serial.h usart_serial.c
  group src/asf/common/services/serial/sam_uart
    src/asf/common/services/serial/sam_uart/: uart_serial.h
  group src/asf/common/services/slcd
    src/asf/common/services/slcd/: lcd_driver.c lcd_driver.h
  group src/asf/common/services/sleepmgr
    src/asf/common/services/sleepmgr/: sleepmgr.h
  group src/asf/common/services/sleepmgr/sam
    src/asf/common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group src/asf/common/services/spi
    src/asf/common/services/spi/: spi_master.h
  group src/asf/common/services/spi/sam_spi
    src/asf/common/services/spi/sam_spi/: spi_master.c spi_master.h
  group src/asf/common/services/twi
    src/asf/common/services/twi/: twi_master.h twi_slave.h
  group src/asf/common/services/twi/sam_twi
    src/asf/common/services/twi/sam_twi/: twi_master.h twi_slave.h
  group src/asf/common/utils
    src/asf/common/utils/: interrupt.h
  group src/asf/common/utils/interrupt
    src/asf/common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group src/asf/common/utils/stdio
    src/asf/common/utils/stdio/: read.c write.c
  group src/asf/common/utils/stdio/stdio_serial
    src/asf/common/utils/stdio/stdio_serial/: stdio_serial.h
  group src/asf/sam/boards
    src/asf/sam/boards/: init.c
  group src/asf/sam/drivers/ipc
    src/asf/sam/drivers/ipc/: ipc.c ipc.h
  group src/asf/sam/drivers/matrix
    src/asf/sam/drivers/matrix/: matrix.c matrix.h
  group src/asf/sam/drivers/pdc
    src/asf/sam/drivers/pdc/: pdc.c pdc.h
  group src/asf/sam/drivers/pio
    src/asf/sam/drivers/pio/: pio.c pio.h pio_handler.c pio_handler.h
  group src/asf/sam/drivers/pmc
    src/asf/sam/drivers/pmc/: pmc.c pmc.h sleep.h
  group src/asf/sam/drivers/pwm
    src/asf/sam/drivers/pwm/: pwm.c pwm.h
  group src/asf/sam/drivers/rstc
    src/asf/sam/drivers/rstc/: rstc.c rstc.h
  group src/asf/sam/drivers/rtc
    src/asf/sam/drivers/rtc/: rtc.c rtc.h
  group src/asf/sam/drivers/rtt
    src/asf/sam/drivers/rtt/: rtt.c rtt.h
  group src/asf/sam/drivers/slcd
    src/asf/sam/drivers/slcd/: slcd.c slcd.h
  group src/asf/sam/drivers/spi
    src/asf/sam/drivers/spi/: spi.c spi.h
  group src/asf/sam/drivers/supc
    src/asf/sam/drivers/supc/: supc.c supc.h
  group src/asf/sam/drivers/twi
    src/asf/sam/drivers/twi/: twi.c twi.h
  group src/asf/sam/drivers/uart
    src/asf/sam/drivers/uart/: uart.c uart.h
  group src/asf/sam/drivers/usart
    src/asf/sam/drivers/usart/: usart.c usart.h
  group src/asf/sam/drivers/wdt
    src/asf/sam/drivers/wdt/: wdt.c wdt.h
  group src/asf/sam/utils
    src/asf/sam/utils/: compiler.h parts.h status_codes.h
  group src/asf/sam/utils/preprocessor
    src/asf/sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group src/asf/thirdparty/CMSIS
    src/asf/thirdparty/CMSIS/: CMSIS END USER LICENCE AGREEMENT.pdf license.txt README.txt
  group src/asf/thirdparty/CMSIS/Include
    src/asf/thirdparty/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group src/asf/thirdparty/CMSIS/Lib/GCC
    src/asf/thirdparty/CMSIS/Lib/GCC/: libarm_cortexM4l_math.a
  group src/at90e_xx
    src/at90e_xx/: at90e_xx.c at90e_xx.h
  group src/basetimer
    src/basetimer/: basetime.c basetime.h
  group src/checkmajorpara
    src/checkmajorpara/: checkmajorpara.c checkmajorpara.h
  group src/communication
    src/communication/: comprocess.c comprocess.h
  group src/config
    src/config/: conf_board.h conf_clock.h conf_meter.c conf_meter.h conf_sleepmgr.h conf_spi_master.h conf_uart_serial.h
  group src/display
    src/display/: display.c display.h
  group src/e2prom
    src/e2prom/: E2define.h eeprom.c eeprom.h
  group src/energy
    src/energy/: energy.c energy.h
  group src/kenerl
    src/kenerl/: task.c task.h
  group src/meter_math
    src/meter_math/: meter_math.c meter_math.h
  group src/readrtc
    src/readrtc/: readrtc.c readrtc.h
  group src/secondproc
    src/secondproc/: secondpro.c secondproc.h
